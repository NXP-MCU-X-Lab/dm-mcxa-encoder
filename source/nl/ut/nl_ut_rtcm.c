#include "nl.h"
#include "nl_ut.h"
#include "rtklib.h"


static void dump_obs(obs_t *obs)
{
    int i=0;
    uint8_t buf[512];
    for (i = 0; i < obs->n; i++)
    {
        nl_obsd2str(buf, &obs->data[i], 'N');
        printf("%s", buf);
    }
}

int nl_ut_rtcm(int argc, char** argv)
{
    size_t i=0;
    int ret;
    rtcm_t rtcm1 = {0}, rtcm2 = {0};
    init_rtcm(&rtcm1);
    init_rtcm(&rtcm2);

    uint8_t rtcm_1005[] = {0xD3, 0x00, 0x13, 0x3E, 0xD7, 0xD3, 0x02, 0x02, 0x98, 0x0E, 0xDE, 0xEF, 0x34, 0xB4, 0xBD, 0x62, 0xAC, 0x09, 0x41, 0x98, 0x6F, 0x33, 0x36, 0x0B, 0x98};

    uint8_t rtcm_1074[] = {0xD3,0x00,0x8A,0x43,0x20,0x00,0x40,0x7F,0x79,0x82,0x00,0x20,0x00,0x22,0x80,0x65,0x80,0x00,0x00,0x00,0x20,0x20,0x00,0x00,0x7F,0xFF,0xA7,0x22,0x26,0x26,0x22,0xA6,0xA2,0xA3,0x20,0xFD,0xDC,0x05,0x9F,0x5B,0x1B,0xC6,0x36,0x1C,0x86,0x77,0x0E,0x32,0x33,0x7C,0x61,0x97,0xB4,0x0F,0x5E,0x7F,0xE6,0xBF,0xDF,0xF8,0x73,0xF1,0x3A,0x5F,0x88,0xBD,0x49,0x6B,0x82,0xBC,0xA6,0xC4,0xCD,0x85,0x86,0xFD,0xF4,0x1A,0xC0,0xFF,0xB8,0x38,0x01,0x77,0xCC,0x78,0x42,0x7D,0xEC,0xC5,0x40,0x18,0xA1,0x81,0x7B,0xEC,0x86,0x04,0x76,0x0F,0xEE,0x28,0x53,0x6E,0xE0,0x84,0x36,0x09,0x22,0x26,0x0C,0x72,0x80,0xD3,0x4C,0xC2,0x8E,0x7A,0x7F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x80,0x00,0x57,0x4E,0x18,0x59,0x3D,0x75,0xE5,0x8D,0xD3,0xE7,0x86,0x58,0x80,0x71,0xCE,0x42};


//    for (i = 0; i < sizeof(rtcm_1005); i++)
//    {
//        ret = input_rtcm3(&rtcm1, rtcm_1005[i]);

//        if(ret)
//        {
//             NL_TRACE("RTKLIB: ret:%d, stid=%4d, ecef=%.3f, %.3f, %.3f\r\n", ret, rtcm1.staid, rtcm1.sta.pos[0], rtcm1.sta.pos[1], rtcm1.sta.pos[2]);
//        }
//    }


//    for (i = 0; i < sizeof(rtcm_1005); i++)
//    {
//       ret = nl_input_rtcm3(&rtcm2, rtcm_1005[i]);

//       if(ret)
//       {
//            NL_TRACE("NL: ret:%d, stid=%4d, ecef=%.3f, %.3f, %.3f\r\n", ret, rtcm2.staid, rtcm2.sta.pos[0], rtcm2.sta.pos[1], rtcm2.sta.pos[2]);
//       }
//    }

    for (i = 0; i < sizeof(rtcm_1074); i++)
    {
        ret = input_rtcm3(&rtcm2, rtcm_1074[i]);
        if(ret)
        {
            NL_TRACE("RTKLIB: ret:%d", ret);
        }

    }
    dump_obs(&rtcm2.obs);

    NL_TRACE("*********\r\n");
    for (i = 0; i < sizeof(rtcm_1074); i++)
    {
        ret = nl_input_rtcm3(&rtcm1, rtcm_1074[i]);

        if(ret)
        {
            NL_TRACE("NL: ret:%d", ret);
        }
    }

    dump_obs(&rtcm1.obs);


//    NL_TRACE("nl_ut_rtcm\r\n");
//    init_rtcm(&rtcm);
//    for (i = 0; i < sizeof(rtcm_1074); i++)
//    {
//        ret = nl_input_rtcm3(&rtcm, rtcm_1074[i]);
//        if(ret)
//        {
//            NL_TRACE("nl_input_rtcm3 ret:%d\r\n", ret);
//            dump_obs(&rtcm.obs);
//            if(ret == 5) NL_TRACE("msg1005: staid=%4d ecef=%.3f %.3f %.3f", rtcm.staid, rtcm.sta.pos[0], rtcm.sta.pos[1], rtcm.sta.pos[2]);
//        }
//    }
    return 0;
}
