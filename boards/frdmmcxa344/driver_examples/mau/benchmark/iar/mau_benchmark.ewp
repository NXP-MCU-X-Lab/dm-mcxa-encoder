# IAR project mau_benchmark.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA344 NXP MCXA344
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXA344VLL; MCXA344_SERIES; DISABLEFLOAT16
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MCXA344/drivers; ../../../../../../CMSIS/DSP/Include; ../../../../../../CMSIS/DSP/PrivateInclude; ../../../../../../CMSIS/DSP/Source/DistanceFunctions; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MCXA344; ../../../../../../devices/MCXA344/periph3; ../../../../../../devices/MCXA344/utilities/debug_console_lite; ../../../../../../devices/MCXA344/utilities/str; ../../../../../../components/uart
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MCXA344VLL; MCXA344_SERIES
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: mau_benchmark.out
  ILINK.IlinkIcfFile: MCXA344_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXA344VLL; MCXA344_SERIES; DISABLEFLOAT16
  ICCARM.CCOptLevel: 3
  group source
    ../: mau_benchmark.c mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.h pin_mux.c hardware_init.c app.h
  group drivers
    ../../../../../../devices/MCXA344/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_mau.c fsl_mau.h fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/DSP/Include
    ../../../../../../CMSIS/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
  group CMSIS/DSP/Include/dsp
    ../../../../../../CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h window_functions.h
  group CMSIS/DSP/PrivateInclude
    ../../../../../../CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
  group CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../../CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group CMSIS/DSP/Source/BayesFunctions
    ../../../../../../CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CMSIS/DSP/Source/CommonTables
    ../../../../../../CMSIS/DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group CMSIS/DSP/Source/ControllerFunctions
    ../../../../../../CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group CMSIS/DSP/Source/DistanceFunctions
    ../../../../../../CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c arm_boolean_distance_template.h DistanceFunctionsF16.c
  group CMSIS/DSP/Source/FastMathFunctions
    ../../../../../../CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group CMSIS/DSP/Source/FilteringFunctions
    ../../../../../../CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group CMSIS/DSP/Source/InterpolationFunctions
    ../../../../../../CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group CMSIS/DSP/Source/MatrixFunctions
    ../../../../../../CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group CMSIS/DSP/Source/QuaternionMathFunctions
    ../../../../../../CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group CMSIS/DSP/Source/SVMFunctions
    ../../../../../../CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group CMSIS/DSP/Source/StatisticsFunctions
    ../../../../../../CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group CMSIS/DSP/Source/SupportFunctions
    ../../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group CMSIS/DSP/Source/TransformFunctions
    ../../../../../../CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group CMSIS/DSP/Source/WindowFunctions
    ../../../../../../CMSIS/DSP/Source/WindowFunctions/: WindowFunctions.c
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MCXA344/: fsl_device_registers.h MCXA344.h MCXA344_features.h MCXA344_COMMON.h system_MCXA344.c system_MCXA344.h
  group device/periph3
    ../../../../../../devices/MCXA344/periph3/: PERI_ADC.h PERI_AOI.h PERI_CAN.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FMC.h PERI_FMU.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MAU.h PERI_MRCC.h PERI_OPAMP.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_RTC.h PERI_SCG.h PERI_SMARTDMA.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group startup
    ../../../../../../devices/MCXA344/: startup_MCXA344.c
  group utilities
    ../../../../../../devices/MCXA344/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../devices/MCXA344/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MCXA344/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group doc
    ../: readme.md example_board_readme.md
