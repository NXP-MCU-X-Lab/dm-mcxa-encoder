# IAR project lpi2c_edma_b2b_transfer_master.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA344 NXP MCXA344
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXA344VLL; MCXA344_SERIES
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../../../devices/MCXA344/drivers; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../devices/MCXA344; ../../../../../../../devices/MCXA344/periph3; ../../../../../../../devices/MCXA344/utilities/debug_console_lite; ../../../../../../../devices/MCXA344/utilities/str; ../../../../../../../components/uart
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MCXA344VLL; MCXA344_SERIES
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: lpi2c_edma_b2b_transfer_master.out
  ILINK.IlinkIcfFile: MCXA344_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXA344VLL; MCXA344_SERIES
  ICCARM.CCOptLevel: 3
  group source
    ../: lpi2c_edma_b2b_transfer_master.c mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.h pin_mux.c hardware_init.c app.h
  group drivers
    ../../../../../../../devices/MCXA344/drivers/: fsl_clock.c fsl_clock.h fsl_edma_soc.c fsl_edma_soc.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_edma.h fsl_edma_core.h fsl_edma.c fsl_gpio.h fsl_gpio.c fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../../../devices/MCXA344/: fsl_device_registers.h MCXA344.h MCXA344_features.h MCXA344_COMMON.h system_MCXA344.c system_MCXA344.h
  group device/periph3
    ../../../../../../../devices/MCXA344/periph3/: PERI_ADC.h PERI_AOI.h PERI_CAN.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FMC.h PERI_FMU.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MAU.h PERI_MRCC.h PERI_OPAMP.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_RTC.h PERI_SCG.h PERI_SMARTDMA.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group startup
    ../../../../../../../devices/MCXA344/: startup_MCXA344.c
  group utilities
    ../../../../../../../devices/MCXA344/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../../devices/MCXA344/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../../devices/MCXA344/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group doc
    ../: readme.md example_board_readme.md
