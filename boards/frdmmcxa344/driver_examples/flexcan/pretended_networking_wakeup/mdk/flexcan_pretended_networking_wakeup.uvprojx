# Keil uVision project flexcan_pretended_networking_wakeup.uvprojx, settings and files
target flexcan_pretended_networking_wakeup debug (6220000::V6.22::ARMCLANG)
  device: MCXA344VLL NXP
  pack: NXP.MCXA344_DFP.21.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: flexcan_pretended_networking_wakeup.out
  AfterMake: fromelf.exe --output "$Lflexcan_pretended_networking_wakeup.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, FLEXCAN_WAIT_TIMEOUT=1000, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA344VLL, MCXA344_SERIES
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MCXA344/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MCXA344;../../../../../../devices/MCXA344/periph3;../../../../../../devices/MCXA344/utilities/debug_console_lite;../../../../../../devices/MCXA344/utilities/str;../../../../../../components/uart
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA344VLL, MCXA344_SERIES
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x6000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x4002000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x4000000 size 0x2000
  scatter file: MCXA344_flash.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: flexcan_pretended_networking_wakeup.c mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.h pin_mux.c hardware_init.c app.h
  group drivers
    ../../../../../../devices/MCXA344/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcan.h fsl_flexcan.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_cmc.c fsl_cmc.h fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MCXA344/: fsl_device_registers.h MCXA344.h MCXA344_features.h MCXA344_COMMON.h system_MCXA344.c system_MCXA344.h
  group device/periph3
    ../../../../../../devices/MCXA344/periph3/: PERI_ADC.h PERI_AOI.h PERI_CAN.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FMC.h PERI_FMU.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MAU.h PERI_MRCC.h PERI_OPAMP.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_RTC.h PERI_SCG.h PERI_SMARTDMA.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group startup
    ../../../../../../devices/MCXA344/: startup_MCXA344.c
  group utilities
    ../../../../../../devices/MCXA344/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MCXA344/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MCXA344/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MCXA344/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group doc
    ../: readme.md example_board_readme.md
target flexcan_pretended_networking_wakeup release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA344VLL NXP
  pack: NXP.MCXA344_DFP.21.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: flexcan_pretended_networking_wakeup.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, FLEXCAN_WAIT_TIMEOUT=1000, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA344VLL, MCXA344_SERIES
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA344VLL, MCXA344_SERIES
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x6000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: ROM 0x4002000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x4000000 size 0x2000
  scatter file: MCXA344_flash.scf
  link misc: as above
