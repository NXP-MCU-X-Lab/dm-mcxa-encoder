# Keil uVision project ind_encoder.uvprojx, settings and files
target ind_encoder (6230000::V6.23::ARMCLANG)
  device: MCXA343VLH NXP
  pack: NXP.MCXA343_DFP.25.09.00
  cpu: IRAM(0x20000000,0x4000) IRAM2(0x04000000,0x2000) IROM(0x03000000,0x6000) IROM2(0x00000000,0x01e000) XRAM(0x04002000,0x2000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: ind_encoder +hex
  AfterMake: fromelf.exe --output "$Lhello_world.bin" --bincombined "#L"
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA344VLL, MCXA344_SERIES SDK_DEBUGCONSOLE_UART
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: board;source;CMSIS;CMSIS/m-profile;component/uart;device;device/periph3;drivers;utilities;utilities/debug_console_lite;utilities/str;.\source\nl;.\source\nl\rcv;.\middleware\freemaster\src\common;.\middleware\freemaster\src\drivers\mcuxsdk\serial;.\middleware\freemaster\src\platforms\gen32le
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA344VLL, MCXA344_SERIES
  asm include: source;CMSIS;CMSIS/m-profile;component/uart;device;device/periph3;drivers;utilities;utilities/debug_console_lite;utilities/str
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x6000
  memory RVCT5: ROM 0x0 size 0x1e000
  memory RVCT6: RAM 0x4002000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x4000000 size 0x2000
  scatter file: MCXA344/mdk/MCXA344_flash.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
--remove
  group CMSIS
    CMSIS/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    CMSIS/m-profile/: armv8m_mpu.h cmsis_armclang_m.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MCXA344.h MCXA344_COMMON.h MCXA344_features.h system_MCXA344.c system_MCXA344.h
  group device/periph3
    device/periph3/: PERI_ADC.h PERI_AOI.h PERI_CAN.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FMC.h PERI_FMU.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MAU.h PERI_MRCC.h PERI_OPAMP.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_RTC.h PERI_SCG.h PERI_SMARTDMA.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group drivers
    drivers/: fsl_clock.c fsl_common.c fsl_common_arm.c fsl_gpio.c fsl_lpuart.c fsl_reset.c fsl_spc.c
    ./drivers/: fsl_inputmux.c fsl_lpadc.c fsl_ctimer.c fsl_opamp.c fsl_mau.c fsl_edma.c fsl_edma_soc.c fsl_lpuart_edma.c
  group source
    ./source/: app_encoder.c clock_config.c hardware_init.c main.c pin_mux.c app_sampler.c app_adc.c mau_atan2.c app_tformat.c freemaster_example.c freemaster_cfg.h
  group startup
    startup/: startup_MCXA344.c
  group utilities/debug_console_lite
    utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities
    utilities/: fsl_assert.c fsl_assert.h fsl_memcpy.S
  group utilities/str
    utilities/str/: fsl_str.c fsl_str.h
  group freemaster/common
    ./middleware/freemaster/src/common/: freemaster_appcmd.c freemaster_can.c freemaster_net.c freemaster_pdbdm.c freemaster_pipes.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sha.c freemaster_tsa.c freemaster_ures.c freemaster_utils.c
  group freemaster/serial
    ./middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpuart.c
